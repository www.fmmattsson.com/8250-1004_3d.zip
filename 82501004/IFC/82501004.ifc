Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Default Project
Time: 2011-01-07T18:20:03
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: FMM 82501004, 82501004_IFC:FMM 82501004:FMM 82501004:111937
In: Level 1
PSet_Revit_Dimensions - Mounting Height: 1100 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 9
PSet_Revit_Type_Identity Data - VVS: -; URL: www.fmmattsson.com; RSK: 8343316; NRF: -; Model: 8250-1004; Manufacturer: FM Mattsson; LVI: -; Family: FM 9000E Bla; EAN: 7391887228681; Description: Safety Mixer For Shower / 40 c/c, Black handle
